FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://uart4.patch"
