FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://i2c_tools.cfg"
SRC_URI += "file://pkill.cfg"
SRC_URI += "file://devmem.cfg"
SRC_URI += "file://arping.cfg"

