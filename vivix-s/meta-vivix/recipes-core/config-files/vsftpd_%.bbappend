FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://vsftpd.ftpusers"
SRC_URI += "file://vsftpd.user_list"

